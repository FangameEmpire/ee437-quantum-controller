v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -140 -80 0 0 {name=p7 lab=iin}
C {devices/iopin.sym} -230 -10 0 0 {name=p2 lab=agnd}
C {devices/iopin.sym} -180 20 0 0 {name=p3 lab=avdd}
C {devices/ipin.sym} 0 -30 0 1 {name=p5 lab=vin}
C {devices/opin.sym} -10 -30 0 1 {name=p6 lab=vout}
