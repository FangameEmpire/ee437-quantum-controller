v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 40 -100 40 -80 {}
N 40 -20 40 0 {}
C {devices/ind.sym} 40 -50 0 0 {name=L1
m=1
value=1n
footprint=1206
device=inductor}
C {devices/iopin.sym} 40 -100 0 0 {name=p1 lab=p0}
C {devices/iopin.sym} 40 0 0 0 {name=p2 lab=m0}
