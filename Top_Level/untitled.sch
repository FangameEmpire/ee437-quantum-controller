v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -20 -100 0 0 {name=p2 lab=Clk}
C {devices/opin.sym} 20 -180 0 0 {name=p3 lab=VoutQ}
C {devices/noconn.sym} -20 -100 0 1 {name=l2}
C {devices/noconn.sym} -20 -60 0 1 {name=l3}
C {devices/noconn.sym} -20 -40 0 1 {name=l4}
C {devices/ipin.sym} -20 -180 0 0 {name=p5 lab=LNA_D}
C {devices/ipin.sym} -20 -200 0 0 {name=p6 lab=Vin}
C {devices/ipin.sym} -20 -220 0 0 {name=p7 lab=LNA_S}
C {devices/opin.sym} 20 -220 0 0 {name=p8 lab=VoutI}
C {devices/noconn.sym} -20 -180 0 1 {name=l5}
C {devices/noconn.sym} -20 -200 0 1 {name=l6}
C {devices/noconn.sym} -20 -220 0 1 {name=l7}
C {devices/noconn.sym} 20 -220 0 0 {name=l1}
C {devices/noconn.sym} 20 -180 0 0 {name=l8}
C {devices/ipin.sym} -20 -120 0 0 {name=p9 lab=AMP_En}
C {devices/noconn.sym} -20 -120 0 1 {name=l9}
C {devices/ipin.sym} -20 -140 0 0 {name=p10 lab=LNA_En}
C {devices/noconn.sym} -20 -140 0 1 {name=l10
lab=LNA_En}
C {devices/noconn.sym} -20 -20 0 1 {name=l11}
C {devices/iopin.sym} -20 -60 0 1 {name=p1 lab=avdd}
C {devices/iopin.sym} -20 -40 0 1 {name=p4 lab=agnd}
C {devices/iopin.sym} -20 -20 0 1 {name=p11 lab=ibias_n_50u}
